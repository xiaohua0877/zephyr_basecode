# Keil uVision project Project.uvprojx, settings and files
target STM32F746G_Discovery_FLASH (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: zephyr
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group arch
    ../../arch/arm/core/: __aeabi_atexit.c fatal.c fault.c irq_init.c irq_manage.c irq_offload.c swap.c sys_fatal_error_handler.c thread.c thread_abort.c
    ../../arch/arm/core/cortex_m/: exc_manage.c nmi.c prep_c.c scb.c nmi_on_reset.S reset.S vector_table.S
    ../../arch/arm/core/cortex_m/mpu/: arm_core_mpu.c arm_mpu.c arm_mpu_v7_internal.h arm_mpu_v8_internal.h nxp_mpu.c
  group sample
    ../hg701/src/: hello_main.c led_main.c
  group kernel
    ../../kernel/: atomic_c.c compiler_stack_protect.c device.c errno.c idle.c init.c int_latency_bench.c mailbox.c mem_domain.c mem_slab.c mempool.c msg_q.c mutex.c pipes.c poll.c queue.c sched.c sem.c smp.c stack.c system_work_q.c thread.c thread_abort.c timeout.c timer.c userspace.c userspace_handler.c version.c work_q.c
software components: CMSIS:CORE 4.3.0
